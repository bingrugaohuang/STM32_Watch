# Keil uVision project STM32_Watch.uvprojx, settings and files
target STM32_Watch (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: STM32_Watch +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../BSP;../OSAL/Inc;../Service/Inc;../APP/Inc;../APP/Inc/ui;../APP/Inc/tasks;../APP/Inc/modules;../APP/Inc/common
  asm include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c i2c.c rtc.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group OSAL
    ../OSAL/Src/: osal.c
    ../OSAL/Inc/: osal.h
  group BSP
    ../BSP/: OLED.c OLED.h OLED_Data.c OLED_Data.h Key.c Key.h MPU6050.c MPU6050.h MPU6050_Reg.h
  group APP/Src
    ../APP/Src/: menu.c
  group APP/Tasks
    ../APP/Tasks/: Flashlight.c MPU6050_Task.c Setting.c ShowMenu.c UI.c Game.c Time_Task.c
  group APP/APP
    ../APP/APP/: ScreenBright.c StopWach.c AlarmUI.c dino.c Gradienter.c Set_StackMonitor.c SetTime.c ShowAngle.c ShowFrames.c TranAnime.c
  group Service/Src
    ../Service/Src/: AlarmService.c SleepManager.c TaskMgr.c StackMonitor_Task.c Log.c
  group APP/Inc/ui
    ../APP/Inc/ui/: AlarmUI.h UI.h
  group APP/Inc/tasks
    ../APP/Inc/tasks/: Flashlight.h Game.h MPU6050_Task.h Setting.h ShowMenu.h task_entry.h Time_Task.h
  group Service/Inc
    ../Service/Inc/: AlarmService.h SleepManager.h TaskMgr.h StackMonitor_Task.h Log.h
  group APP/Inc/modules
    ../APP/Inc/modules/: dino.h Gradienter.h ScreenBright.h Set_StackMonitor.h SetTime.h ShowAngle.h ShowFrames.h StopWatch_APP.h TranAnime.h menu.h
  group APP/Inc/common
    ../APP/Inc/common/: app_common.h app_handles.h app_types.h
software components: CMSIS:CORE 5.0.1
