# Keil uVision project STM32_Watch_Rewrite.uvprojx, settings and files
target STM32_Watch_Rewrite (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: STM32_Watch_Rewrite +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../User/Middlewares/FreeRTOS/include;../User/Middlewares/FreeRTOS/portable/RVDS/ARM_CM3;../User/Middlewares/FreeRTOS/cfg;../User/Middlewares/Debug;../User/Drivers;../User/OSAL;../User/Services;../User/Middlewares/Button;../User/Middlewares/I2C;../User/BSP;../User/Common;../User/Middlewares/Menu;../User/APP/Compute
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c i2c.c rtc.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Middlewares/FreeRTOS/Src
    ../User/Middlewares/FreeRTOS/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../User/Middlewares/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../User/Middlewares/FreeRTOS/portable/MemMang/: heap_4.c
  group APP/Sys
    ../User/APP/SYS/: task_main.c
  group User/Drivers
    ../User/Drivers/: serial.c i2c_test.c oled_driver.c oled_data.c oled_strings_gbk.c mpu6050_driver.c
  group User/OSAL
    ../User/OSAL/: osal.c
  group User/Services
    ../User/Services/: log.c button_service.c display_service.c rtc_service.c flashlight_service.c mpu6050_service.c sleepmgr_service.c stackmonitor_service.c
  group User/BSP
    ../User/BSP/: bsp_button.c bsp_i2c1_sw.c bsp_i2c1_hw.c bsp_pwm.c bsp_exti.c bsp_i2c2_sw.c bsp_i2c2_hw.c
  group Middlewares/Debug
    ../User/Middlewares/Debug/: hardfault_debug.c
  group Middlewares/Button
    ../User/Middlewares/Button/: button.c
  group Middlewares/Menu
    ../User/Middlewares/Menu/: menu_engine.c
  group APP/Menu
    ../User/APP/Menu/: menu_home.c menu_applist.c menu_stopwatch.c menu_flashlight.c menu_gradienter.c
  group APP/MPU
    ../User/APP/Compute/: mpu_angle.c mpu_stepcnt.c
software components: CMSIS:CORE 4.3.0
